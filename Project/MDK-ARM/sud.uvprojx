# Keil uVision project sud.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: sud +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: .;..\..\Core;..\..\Libraries\CMSIS;..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\BSP;..\..\APP\LED;..\..\APP\KEY;..\..\APP\EXTI;..\..\APP\time;..\..\APP\pwm;..\..\APP\1608;..\..\APP\esp8266\ESP8266_drive;..\..\APP\esp8266\ESP8266_Public;..\..\APP\esp8266\STA_TCPClent_Test;..\..\APP\OELD;..\..\APP\MLX90614;..\..\APP\MFRC522;..\..\APP\SPI_Driver;..\..\APP\BATTERY;..\..\APP\DATA_FUSION;..\..\APP\TASK_WATCHDOG;..\..\APP\SYSTEM_TEST;..\..\APP\FLASH_STORE;..\..\APP\RTC;..\..\APP\ANOMALY;..\..\APP\IIC(24C02);..\..\FreeRTOS\Source\include;..\..\FreeRTOS\Source\portable\RVDS\ARM_CM3
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0xFC00
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ../../Core/: main.c stm32f10x_it.c
  group Startup
    ../../Libraries/CMSIS/: startup_stm32f10x_md.s
  group Driver
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_gpio.c stm32f10x_rcc.c misc.c stm32f10x_exti.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_dma.c
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group APP
    ../../APP/LED/: led.c
    ../../APP/time/: time.c
    ../../APP/esp8266/STA_TCPClent_Test/: sta_tcpclent_test.c
    ../../APP/esp8266/ESP8266_Public/: esp8266_public.c
    ../../APP/esp8266/ESP8266_drive/: esp8266_drive.c
    ../../APP/OELD/: oled_iic.c
    ../../APP/1608/: 1608.c
    ../../APP/KEY/: key.c
  group Public
    ../../BSP/: system.c delay_timer.c usart.c
  group Architecture_v2
    ../../APP/MLX90614/: mlx90614.c
    ../../APP/MFRC522/: mfrc522.c
    ../../APP/SPI_Driver/: spi_driver.c
    ../../APP/BATTERY/: battery.c
    ../../APP/DATA_FUSION/: data_fusion.c fusion_policy.c
    ../../APP/TASK_WATCHDOG/: task_watchdog.c
    ../../APP/SYSTEM_TEST/: system_test.c
    ../../APP/FLASH_STORE/: flash_store.c
    ../../APP/RTC/: rtc_driver.c
    ../../APP/ANOMALY/: anomaly_detect.c
    ../../APP/IIC(24C02)/: iic.c
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_adc.c stm32f10x_spi.c stm32f10x_flash.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_bkp.c stm32f10x_rtc.c
    ../../FreeRTOS/Source/: list.c tasks.c queue.c event_groups.c timers.c
    ../../FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
    ../../APP/pwm/: pwm.c
